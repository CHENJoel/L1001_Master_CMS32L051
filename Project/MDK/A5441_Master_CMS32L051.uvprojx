# Keil uVision project A5441_Master_CMS32L051.uvprojx, settings and files
target CMS32L051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051TS20 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: L1001_Master +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\USER\Include;..\..\Driver\inc;..\USER\mcu_sdk;..\USER\ota;..\USER\internal_memory;..\USER\external_memory;..\USER\debug;..\USER\app;..\USER\flashapp;..\USER\master;..\USER\play;..\USER\slave;..\USER\factory;..\USER\version;..\USER\parse
  memory RVCT4: ROM 0x5000 size 0xb000
  memory RVCT9: RAM 0x20000200 size 0x1e00
  group Source
    ../USER/Source/: main.c A5441_Master.c FIFO.c Color.c image.c IR.C Light.c KEY.C Com.c delay.c FFT.c uart.c Sys.c wave.c motion.c colorbox.c
  group SDK
    ../USER/mcu_sdk/: homekit.c mcu_api.c protocol.c system.c
  group Driver
    ../../Driver/src/: retarget.c sci.c sci_user.c gpio.c tim4.c tim4_user.c adc.c adc_user.c flash.c flash_user.c rtc.c rtc_user.c dma.c
  group user_external storage
    ../USER/external_memory/: driver_spi.c driver_spi.h driver_w25qxx.c driver_w25qxx.h MEM.c MEM.h memory.c memory.h user_memory.c user_memory.h
  group user_internal storage
    ../USER/internal_memory/: default_data.c default_data.h internal_memory.c internal_memory.h
  group user_app
    ../USER/app/: appfunction.c appfunction.h comapp.c comapp.h
  group user_ota
    ../USER/ota/: ota.c ota.h newota.c newota.h
  group user_debug
    ../USER/debug/: debug.c debug.h printlog.c printlog.h
  group user_flashapp
    ../USER/flashapp/: flashapp.c flashapp.h
  group user_master
    ../USER/master/: master.c master.h
  group user_play
    ../USER/play/: play.c play.h
  group user_device
    ../USER/slave/: slave.c slave.h
  group user_factory
    ../USER/factory/: factory.c factory.h
  group user_version
    ../USER/version/: version.c version.h
  group user_parse
    ../USER/parse/: parse.c parse.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
